# IAR project uart_dma_cc254x.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: CC2541F256 CC2541F256
  ICC8051.CCDefines: chip=2541
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: source; source\components
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: C:\Texas Instruments\BLE-CC254x-1.4.2.2\Projects\ble\common\cc2540\ti_51ew_cc2540b.xcl
configuration primary (8051, debug)
  as the first configuration, except:
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2541F256_banked.xcl
  group (top)
    source/components/: hal_wait.c
    source/: uart_dma.c
