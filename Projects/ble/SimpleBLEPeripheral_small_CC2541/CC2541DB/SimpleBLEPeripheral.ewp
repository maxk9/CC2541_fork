# IAR project SimpleBLEPeripheral.ewp, settings and files
configuration CC2541DK-MINI Keyfob (8051, debug)
  General.OGChipSelectMenu: CC2541F256 CC2541F256
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=TRUE; HAL_KEY=TRUE; CC2540_MINIDK
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\CC254x\phy; ..\..\..\..\Components\ble\controller\CC254x\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\..\..\Components\ble\ROM; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles\CC254x; ..\..\Profiles\Roles; ..\..\Profiles\SimpleProfile\CC254x; ..\..\Profiles\SimpleProfile; ..\..\Profiles\DevInfo; ..\..\Profiles\Keys\CC254x; ..\..\Profiles\Keys
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
configuration CC2541 (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPLUS_BROADCASTER; HAL_UART=TRUE; HAL_UART_DMA=2; HAL_LED=TRUE; BLINK_LEDS=TRUE; HAL_KEY=TRUE; MAKE_CRC_SHDW; FEATURE_SBL; POWER_SAVING=TRUE
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2541_small; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\CC254x\phy; ..\..\..\..\Components\ble\controller\CC254x\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\..\..\Components\ble\ROM; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles\CC254x; ..\..\Profiles\Roles; ..\..\Profiles\SimpleProfile\CC254x; ..\..\Profiles\SimpleProfile; ..\..\Profiles\DevInfo; ..\..\Profiles\Keys\CC254x; ..\..\Profiles\Keys
  postbuild: "c:\Texas Instruments\BLE-CC254x-1.4.2.2\Projects\ble\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "c:\Texas Instruments\BLE-CC254x-1.4.2.2\Projects\ble\SimpleBLEPeripheral_small_CC2541\CC2541DB\CC2541\Exe\SimpleBLEPeripheral.sim"
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_sbl.xcl
configuration CC2541-OAD-ImgA (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_A; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=TRUE; HAL_LED=FALSE; HAL_KEY=TRUE
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\CC254x\phy; ..\..\..\..\Components\ble\controller\CC254x\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\..\..\Components\ble\ROM; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles\CC254x; ..\..\Profiles\Roles; ..\..\Profiles\SimpleProfile\CC254x; ..\..\Profiles\SimpleProfile; ..\..\Profiles\DevInfo; ..\..\Profiles\Keys\CC254x; ..\..\Profiles\Keys; ..\..\Profiles\OAD
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2541-OAD-ImgA\Exe\SimpleBLEPeripheral.sim"
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgA.xcl
configuration CC2541-OAD-ImgB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_B; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=TRUE; HAL_LED=FALSE; HAL_KEY=TRUE
  ICC8051.CCIncludePath2: as above
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2541-OAD-ImgB\Exe\SimpleBLEPeripheral.sim"
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgB.xcl
configuration CC2541-OAD-Encrypted-ImgA (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_SECURE; FEATURE_OAD_BIM; HAL_IMAGE_A; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=TRUE; HAL_LED=FALSE; HAL_KEY=TRUE
  ICC8051.CCIncludePath2: as above
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2541-OAD-Encrypted-ImgA\Exe\SimpleBLEPeripheral.sim"
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgAe.xcl
configuration CC2541-OAD-Encrypted-ImgB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD_SECURE; FEATURE_OAD_BIM; HAL_IMAGE_B; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=TRUE; HAL_LED=FALSE; HAL_KEY=TRUE
  ICC8051.CCIncludePath2: as above
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2541-OAD-Encrypted-ImgB\Exe\SimpleBLEPeripheral.sim"
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgBe.xcl
  group APP
    ../Source/: OSAL_SimpleBLEPeripheral.c simpleBLEPeripheral.c simpleBLEPeripheral.h SimpleBLEPeripheral_Main.c
  group HAL/Common
    ../../../../Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../../Components/services/saddr/: saddr.h
  group HAL/Target/CC2541_small/config
    ../../../../Components/hal/target/CC2541_small/: hal_board_cfg.h
  group HAL/Target/CC2541_small/drivers
    ../../../../Components/hal/target/CC2541_small/: hal_adc.c hal_aes.c hal_crc.c hal_dma.c hal_flash.c hal_key.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2541_small/includes
    ../../../../Components/hal/target/CC2541_small/: hal_aes.h hal_ccm.h hal_crc.h hal_dma.h hal_mcu.h hal_types.h
  group INCLUDE
    ../../../../Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    ../../../../Components/ble/host/: linkdb.h
    ../../../../Components/ble/controller/CC254x/include/: ll.h phy.h
    ../../common/npi/npi_np/: npi.h
  group LIB
    ../../Libraries/CC2541DB/bin/: CC2541_BLE_peri.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/DevInfo/: devinfoservice.c devinfoservice.h
    ../../Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h peripheralBroadcaster.c peripheralBroadcaster.h
    ../../Include/: gapgattserver.h gattservapp.h
    ../../../../Components/ble/host/: gatt_uuid.c
    ../../Profiles/GATT/: gattservapp_util.c
    ../../Profiles/OAD/: oad.h oad_target.c oad_target.h
    ../../Profiles/Roles/CC254x/: peripheral.c peripheral.h
    ../../Profiles/SimpleProfile/CC254x/: simpleGATTprofile.c
    ../../Profiles/SimpleProfile/: simpleGATTprofile.h
    ../../Profiles/Keys/CC254x/: simplekeys.c
    ../../Profiles/Keys/: simplekeys.h
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2540/: OnBoard.c OnBoard.h
